# Keil uVision project Solar-Tracker-Microcontroller.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAM4S4B Microchip
  pack: Keil.SAM4_DFP.1.6.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00400000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Solar-Tracker-Microcontroller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./SAM4S4B/: SAM4S4B_wdt.h SAM4S4B_uart.h SAM4S4B_twi.h SAM4S4B_tc.h SAM4S4B_sys.h SAM4S4B_supc.h SAM4S4B_spi.h SAM4S4B_rtc.h SAM4S4B_pwm.h SAM4S4B_pmc.h SAM4S4B_pio.h SAM4S4B_adc.h SAM4S4B.h
    ./: main.c motors.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.1.2
